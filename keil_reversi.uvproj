# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c fifo.c gpio_hal.c timer_drv.c timer_hal.c fifo.h gpio_hal.h timer_drv.h timer_hal.h evento.h planificador.h planificador.c io_reserva.h hello_world.c hello_world.h power_hal.c power_hal.h alarma.c alarma.h int_externas_hal.c int_externas_hal.h botones.c botones.h juego.c juego.h visualizar.h visualizar.c
